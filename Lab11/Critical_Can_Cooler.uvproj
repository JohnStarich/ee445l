# Keil uVision project Critical_Can_Cooler.uvproj, settings and files
target Critical Can Cooler V1.0 (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Critical Can Cooler
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s Timer0A.c PLL.c Main.c SysTick.c PLL.h SysTick.h Timer0A.h Timer1A.c Timer1A.h Buttons.h Buttons.c ADCSWTrigger.c ADCSWTrigger.h ST7735.c ST7735.h TEC.c TEC.h
